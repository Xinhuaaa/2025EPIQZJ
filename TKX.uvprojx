# Keil uVision project TKX.uvprojx, settings and files
target TKX (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM4 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: TKX
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: Drivers\STM32F4xx_HAL_Driver\Inc;Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;Drivers\CMSIS\Device\ST\STM32F4xx\Include;Drivers\CMSIS\Include;Middlewares\Third_Party\FreeRTOS\Source\include;Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS_V2;Middlewares\Third_Party\FreeRTOS\Source\portable\GCC\ARM_CM4F;Core\Inc;bsp\log;Application;modules;Middlewares\Third_Party\SEGGER;Application\Chassis;modules\Hwt101;Middlewares\Third_Party\SEGGER\RTT;modules\ADRC;modules\PID;Middlewares\Third_Party\SEGGER\Config;bsp\can;bsp\dwt;modules\ZDT_EmmV5\CAN;Inc;Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;Middlewares\ST\STM32_USB_Device_Library\Core\Inc;Application\Lift;modules\dji_motor;modules\servo;Application\Crawl;modules\ZDT_EmmV5
  asm define: USE_HAL_DRIVER,STM32F407xx
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: d:\TKX\stm32f407vetx_flash.ld
  group APPLICATION
    Application/: Robot_task.c
  group APPLICATION/LIFT
    Application/Lift/: lift.c
  group APPLICATION/CRAWL
    Application/Crawl/: Crawl.c
  group APPLICATION/CHASSIS
    Application/Chassis/: chassis.c
  group BSP/LOG
    bsp/log/: bsp_log.c
  group BSP/DWT
    bsp/dwt/: bsp_dwt.c
  group BSP/CAN
    bsp/can/: bsp_can.c
  group MIDDLEWARES/THIRD_PARTY/SEGGER/RTT
    Middlewares/Third_Party/SEGGER/RTT/: SEGGER_RTT.c SEGGER_RTT_ASM_ARMv7M.s SEGGER_RTT_printf.c
  group MIDDLEWARES/THIRD_PARTY/FREERTOS/SOURCE
    Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group MIDDLEWARES/THIRD_PARTY/FREERTOS/SOURCE/PORTABLE/MEMMANG
    Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group MIDDLEWARES/THIRD_PARTY/FREERTOS/SOURCE/PORTABLE/GCC/ARM_CM4F
    Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F/: port.c
  group MIDDLEWARES/THIRD_PARTY/FREERTOS/SOURCE/CMSIS_RTOS_V2
    Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
  group MIDDLEWARES/ST/STM32_USB_DEVICE_LIBRARY/CORE/SRC
    Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group MIDDLEWARES/ST/STM32_USB_DEVICE_LIBRARY/CLASS/CDC/SRC
    Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group MODULES/ZDT_X42
    modules/ZDT_X42/: ZDT_X42_V2.c
  group MODULES/ZDT_EMMV5
    modules/ZDT_EmmV5/: Emm_V5.c
  group MODULES/ZDT_EMMV5/CAN
    modules/ZDT_EmmV5/CAN/: Emm_V5_CAN.c
  group MODULES/SERVO
    modules/servo/: servo.c
  group MODULES/PID
    modules/PID/: PID.c
  group MODULES/HWT101
    modules/Hwt101/: Hwt101.c
  group MODULES/DJI_MOTOR
    modules/dji_motor/: dji_motor.c
  group MODULES/ADRC
    modules/ADRC/: ADRC.c
  group SRC
    Src/: can.c crc.c dma.c freertos.c gpio.c main.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c stm32f4xx_it.c syscalls.c sysmem.c system_stm32f4xx.c usart.c usbd_cdc_if.c usbd_conf.c usbd_desc.c usb_device.c
  group DRIVERS/STM32F4XX_HAL_DRIVER/SRC
    Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_usb.c
  group <virtual_root>
    ./: startup_stm32f407xx.s
